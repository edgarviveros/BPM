* FILE: nor.sp

* SPICE netlist for "nor" generated by MMI_SUE5.6.29 on Wed Oct 18
*+ 18:13:33 CDT 2017.

.SUBCKT nor A B Y
M_1 Y A gnd gnd n W='3*1u' L='0.6*1u'
M_2 Y B gnd gnd n W='3*1u' L='0.6*1u'
M_3 Y A net_1 vdd p W='12*1u' L='0.6*1u'
M_4 net_1 B vdd vdd p W='12*1u' L='0.6*1u'
.ENDS	$ nor

.GLOBAL gnd vdd
