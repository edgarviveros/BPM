* FILE: nand.sp

* SPICE netlist for "nand" generated by MMI_SUE5.6.29 on Wed Oct 18
*+ 18:14:05 CDT 2017.

.SUBCKT nand A B Y
M_1 net_1 A gnd gnd n W='6*1u' L='0.6*1u'
M_2 Y B net_1 gnd n W='6*1u' L='0.6*1u'
M_3 Y A vdd vdd p W='6*1u' L='0.6*1u'
M_4 Y B vdd vdd p W='6*1u' L='0.6*1u'
.ENDS	$ nand

.GLOBAL gnd vdd
