* FILE: xor2.sp

* SPICE netlist for "xor2" generated by MMI_SUE5.6.29 on Wed Oct 18
*+ 09:55:15 CDT 2017.

.SUBCKT xor2 a b out
M_1 net_4 b vdd vdd p W='12*1u' L='0.6*1u'
M_2 out net_1 net_4 vdd p W='12*1u' L='0.6*1u'
M_3 out a net_6 vdd p W='12*1u' L='0.6*1u'
M_4 net_6 net_3 vdd vdd p W='12*1u' L='0.6*1u'
M_5 net_2 b gnd gnd n W='6*1u' L='0.6*1u'
M_6 net_5 net_3 gnd gnd n W='6*1u' L='0.6*1u'
M_7 out a net_2 gnd n W='6*1u' L='0.6*1u'
M_8 out net_1 net_5 gnd n W='6*1u' L='0.6*1u'
M_9 net_1 a vdd vdd p W='12*1u' L='0.6*1u'
M_10 net_1 a gnd gnd n W='6*1u' L='0.6*1u'
M_11 net_3 b vdd vdd p W='12*1u' L='0.6*1u'
M_12 net_3 b gnd gnd n W='6*1u' L='0.6*1u'
.ENDS	$ xor2

.GLOBAL gnd vdd
